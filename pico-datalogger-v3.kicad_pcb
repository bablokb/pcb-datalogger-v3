# Repository bablokb/pcb-datalogger-v3

File Readme.md:

KiCAD-Designfiles for Version 3 PCB
===================================

Here are the KiCAD (v7) design-files for the Datalogger-V3-PCB.

The PCB supports a
[display-adapter](https://github.com/bablokb/pcb-datalogger-display-adapter)
connected with SURS-cables, or an [adapter connected with normal
DuPont-sockets](https://github.com/bablokb/pcb-datalogger-display-adapter-v2).

Schematic
---------

Layout
------

3D-Views
--------

Printed Case
------------

A printed case is available from <https://github.com/bablokb/3D-datalogger-v3-case>:

Together with a display:

License
-------

[![CC BY-SA 4.0][cc-by-sa-shield]][cc-by-sa]

This work is licensed under a
[Creative Commons Attribution-ShareAlike 4.0 International
License][cc-by-sa].

[![CC BY-SA 4.0][cc-by-sa-image]][cc-by-sa]

[cc-by-sa]: http://creativecommons.org/licenses/by-sa/4.0/
[cc-by-sa-image]: https://licensebuttons.net/l/by-sa/4.0/88x31.png
[cc-by-sa-shield]:
https://img.shields.io/badge/License-CC%20BY--SA%204.0-lightgrey.svg

## KiCad design pico-datalogger-v3.kicad_pcb

Board: 2 copper layers, 130.0 x 65.0 mm, 58 parts (22 on the bottom side), 45 nets.

Parts:
AE1: Antenna_u.FL; U.FL_Hirose_U.FL-R-SMT-1_Vertical
AE2: Antenna_THT
BT1: Coin_Cell; CR2032_Holder
BT2: Battery; BatteryHolder_Keystone_2462_2xAA
C1, C2, C3, C4: 100nF; C_0402_1005Metric
C5, C6: 10µF; C_0603_1608Metric
D1: LED green; LED_0805_2012Metric
D2: LED red; LED_0805_2012Metric
H1, H2, H3, H4: MountingHole; MountingHole_2.5mm
H5, H6: BBox_Mount; MountingHole_3.5_slotted
IC1: LM66200DRLR
J1: JST-PH2 Bat; JST_PH_S2B-PH-SM4-TB_1x02-1MP_P2.00mm_Horizontal
J2: Conn_Pico_Left; PinSocket_1x20_P2.54mm_Vertical
J3: Conn_Pico_Right; PinSocket_1x20_P2.54mm_Vertical
J4: SM06B-GHS-TB_LF_SN; JST_SM06B-GHS-TB_LF_SN
J6: Conn_Display; JST_SUR_BM08B-SURS-TF_1x08-1MP_P0.80mm_Vertical
J9: Conn_I2C0; JST_SH_SM04B-SRSS-TB_1x04-1MP_P1.00mm_Horizontal
J11: Conn_I2C1; JST_SH_SM04B-SRSS-TB_1x04-1MP_P1.00mm_Horizontal
J12: Conn_UART_5V; PinHeader_1x04_P2.54mm_Horizontal
J13: THT_I2C1; PinHeader_1x04_P2.54mm_Vertical
J14: THT_I2C0; PinHeader_1x04_P2.54mm_Vertical
J17: Disp_THT; PinHeader_1x08_P2.54mm_Vertical
JP1: JP_Power; SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm
Q1, Q2: AO3401A; SOT-23
R1, R6: 100K; R_0402_1005Metric
R2, R3, R4, R5, R7, R9, R10: 10K; R_0402_1005Metric
R8: 220Ω; R_0402_1005Metric
R11: 1K; R_0402_1005Metric
R12: 330Ω; R_0402_1005Metric
S1: JS202011JCQN; SW_JS202011JCQN
SW1, SW2, SW3, SW4, SW5: SW_Push; SW_SPST_B3S-1000
U1: 74LVC2G74; X2SON-8_1.4x1mm_P0.35mm
U2: PCF8523T; SOIC-8_3.9x4.9mm_P1.27mm
U4: XTSD
U5: SCD40_Breakout
U6: AHT20
U7: RFM95W-868S2; HOPERF_RFM9XW_SMD
Y1: Crystal; Crystal_SMD_3215-2Pin_3.2x1.5mm

Connections:
+3V3: C3.1, C6.2, J3.5, J4.1, J4.6, J6.8, J9.2 (Vcc), J11.2 (Vcc), J13.2 (Vcc), J14.2 (Vcc), J17.8, JP1.1 (A), R3.1, R4.1, R5.1, R7.1, R8.2, R9.2, R10.2, U4.8 (VCC), U5.2 (VDD), U7.13 (3.3V)
+BATT: C1.1, C2.1, Q1.2 (S), R2.1, S1.3, S1.7, U1.7 (~PRE), U1.8 (VCC), U2.8 (VDD)
/Display_BUSY: J3.10, J6.5, J17.5
/Display_CS: J3.19, J6.1, J17.1, R5.2
/Display_DC: J3.15, J6.4, J17.4
/Display_RST: J3.14, J6.6, J17.6
/GP4_DONE: J2.6, R1.2, U1.1 (CP)
/LoRa/ANT: AE1.1 (In), AE2.1 (A), U7.9 (ANT)
/MISO0: J3.20, R6.1, U4.6 (SD0/MISO)
/MOSI0: J3.16, J6.3, J17.3, U4.5 (CMD/MOSI)
/PC_GATE: Q1.1 (G), U1.5 (Q)
/PS_STATUS: IC1.8 (ST), J3.7
/RX: J2.2, J9.4 (SCL), J12.1, J14.4 (SCL)
/SCLK0: J3.17, J6.2, J17.2, U4.3 (SCK/SCK)
/SD_CS: J3.12, R7.2, U4.2 (SD3/CS)
/TX: J2.1, J9.3 (SDA), J12.2, J14.3 (SDA)
/VBUS: J3.1, J12.3, Q2.1 (G)
/VOUT: IC1.2 (VOUT@1), IC1.7 (VOUT@2), S1.2, S1.6
/VSYS: J3.2, Q2.2 (S)
GND: AE1.2 (Ext), BT1.2 (-), BT2.2 (-), C1.2, C2.2, C3.2, C4.2, C5.2, C6.1, D1.1 (K), D2.1 (K), IC1.1 (GND@1), IC1.4 (ON), IC1.5 (GND@2), J1.2, J2.3, J2.8, J2.13, J2.18, J3.3, J3.8, J3.13, J3.18, J4.2, J4.5, J4.S1 (SHIELD), J4.S2 (SHIELD), J6.7, J9.1 (GND), J11.1 (GND), J12.4, J13.1 (GND), J14.1 (GND), J17.7, R1.1, R6.2, SW1.2, SW2.2, SW3.2, SW4.2, SW5.2, U1.4 (GND), U2.4 (VSS), U4.4 (GND), U5.1 (GND), U6.5 (GND), U7.1 (GND), U7.8 (GND), U7.10 (GND)
Lora_CS: J2.12, U7.5 (NSS)
Lora_DIO0: J2.20, U7.14 (DIO0)
Lora_RST: J2.10, U7.6 (RESET)
MISO1: J2.16, U7.2 (MISO)
MOSI1: J2.15, U7.3 (MOSI)
unnamed: BT1.1 (+), U2.3 (VBAT)
unnamed: BT2.1 (+), IC1.6 (VIN2)
unnamed: D1.2 (A), R11.2
unnamed: D2.2 (A), R12.1
unnamed: IC1.3 (VIN1), J1.1
unnamed: JP1.2 (B), R11.1
unnamed: Q1.3 (D), Q2.3 (D)
unnamed: U1.2 (D), U1.3 (~Q)
unnamed: U2.1 (OSCI), Y1.2
unnamed: U2.2 (OSCO), Y1.1
unnamed: C4.1, C5.1, R8.1, U6.2 (VDD)
RUN: J3.11, SW4.1
SCL: J2.5, J4.4, J11.4 (SCL), J13.4 (SCL), R4.2, R9.1, U2.6 (SCL), U5.3 (SCL), U6.3 (SCL)
SCLK1: J2.14, U7.4 (SCK)
SDA: J2.4, J4.3, J11.3 (SDA), J13.3 (SDA), R3.2, R10.1, U2.5 (SDA), U5.4 (SDA), U6.4 (SDA)
SWA: J2.11, SW1.1
SWB: J2.9, SW2.1
SWC: J2.17, SW3.1
SWD: J2.7, R12.2
~ON: R2.2, SW5.1, U1.6 (~CLR), U2.7 (~INT1/CLKOUT)

File production_files/BOM-no-header-pico-datalogger-v3.csv:

1K,R11,R_0402_1005Metric,C11702
SM06B-GHS-TB_LF_SN,J4,JST_SM06B-GHS-TB_LF_SN,C133065
AO3401A,"Q1,Q2",SOT-23,C15127
100nF,"C1,C2,C3,C4",C_0402_1005Metric,C1525
Conn_I2C1,"J11,J9",JST_SH_SM04B-SRSS-TB_1x04-1MP_P1.00mm_Horizontal,C160404
10µF,"C5,C6",C_0603_1608Metric,C19702
JS202011JCQN,S1,SW_JS202011JCQN,C221665
SW_Push,"SW1,SW2,SW3,SW4,SW5",SW_SPST_B3S-1000,C221869
LED green,D1,LED_0805_2012Metric,C2297
220Ω,R8,R_0402_1005Metric,C25091
330Ω,R12,R_0402_1005Metric,C25104
100K,"R1,R6",R_0402_1005Metric,C25741
10K,"R10,R2,R3,R4,R5,R7,R9",R_0402_1005Metric,C25744
PCF8523T,U2,SOIC-8_3.9x4.9mm_P1.27mm,C2651516
RFM95W-868S2,U7,HOPERF_RFM9XW_SMD,C2844472
JST-PH2 Bat,J1,JST_PH_S2B-PH-SM4-TB_1x02-1MP_P2.00mm_Horizontal,C295747
AHT20,U6,AHT20,C3012622
Battery,BT2,BatteryHolder_Keystone_2462_2xAA,C3029547
Crystal,Y1,Crystal_SMD_3215-2Pin_3.2x1.5mm,C32346
LM66200DRLR,IC1,LM66200DRLR,C3235556
Conn_Pico_Left,"J2,J3",PinSocket_1x20_P2.54mm_Vertical,C429947
Conn_Display,J6,JST_SUR_BM08B-SURS-TF_1x08-1MP_P0.80mm_Vertical,C5143489
74LVC2G74,U1,X2SON-8_1.4x1mm_P0.35mm,C548678
XTSD,U4,XTSD,C7429710
LED red,D2,LED_0805_2012Metric,C84256
Antenna_u.FL,AE1,U.FL_Hirose_U.FL-R-SMT-1_Vertical,C88374
Coin_Cell,BT1,CR2032_Holder,C964777

## Commit log

2025-11-10 initial version of v3 PCB
2025-11-12 fix pin-order for SEN66-connector
2025-11-12 switch to user:JST-PH2
2025-11-12 switch to user:JST-SH4
2025-11-12 update footprint RFM96x
2025-11-12 switch to user:SW_PUSH
2025-11-12 switch to user:JST_SUR_BM08B-SURS-TF_1x08-1MP_P0.80mm_Vertical
2025-11-12 flipped I2C0-THT to back-side
2025-11-12 improved silkscreen
2025-11-13 move AA-holder away from mounting-hole
2025-11-18 connect status-pin of diode to GP28
2025-11-18 initial routing of power and I2C-devices
2025-11-18 initial routing display-connector, on/rst buttons
2025-11-19 swapped SWA/SWB with LoRa-RST/LoRa-CS; initial routing of LoRa and buttons
2025-11-20 swapped additional pins to simplify routing
2025-11-21 added GND-vias for LoRa
2025-11-21 fine tune AHT20 layout and add cutout
2025-11-21 fixes for production files
2025-11-21 added preliminary production-files
2025-11-21 changes due to production-file generation
2025-11-30 use 868-version of LoRa-chip (for iteration-1)
2025-12-12 fixed 3D model for battery-holder
2025-12-12 added images
2026-01-03 updated production-files for datalogger-v3 and images
2026-01-15 updated production-files for datalogger-v3 (with rfm95-868)
2026-01-29 added administrative files
2026-01-29 added .gitignore
2026-02-19 Rev. 3.10: use XSON-8 package for flip-flop
2026-03-13 removed temporary file
2026-04-14 link to display-adapters and 3D-printed cases
2026-04-14 fixed links to images
2026-05-06 added no-header BOM for JLCPCB BOM-Tool
